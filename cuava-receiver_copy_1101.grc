options:
  parameters:
    generate_options: qt_gui
    id: cuava_receiver
    output_language: python
    title: CUAVA beacon receiver
  states: {}

blocks:
- name: Expected_TED_Gain
  id: variable_qtgui_range
  parameters:
    label: Expected TED Gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: baud_rate*200
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: costas_loop
  id: variable_qtgui_range
  parameters:
    label: costas_loop
    start: '0'
    step: '0.001'
    stop: '1'
    value: math.pi/10
  states: {}
- name: freq
  id: variable
  parameters:
    value: 400.65e6
  states: {}
- name: max_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: rrc_bw
  id: variable_qtgui_range
  parameters:
    label: rrc_bw
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.35'
  states: {}
- name: rrc_filter_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: rrc_bw
    gain: '1'
    ntaps: '2000'
    samp_rate: samp_rate
    sym_rate: baud_rate*2
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: '400650000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 38.4e3 * 3
  states: {}
- name: symbol_sync_loop
  id: variable_qtgui_range
  parameters:
    label: symbol_sync_loop
    start: '0'
    step: '0.001'
    stop: '1'
    value: 2*math.pi*0.04
  states: {state: disabled}
- name: symbol_sync_loop
  id: variable_qtgui_range
  parameters:
    label: symbol_sync_loop
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.19022'
  states: {}
- name: usrp_gain
  id: variable_qtgui_range
  parameters:
    comment: 15 if only RX connected
    start: '0'
    step: '1'
    stop: '80'
    value: '15'
  states: {}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: max_gain
    rate: '1'
    reference: '1.0'
    type: complex
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '8'
    gain: '1'
    high_cutoff_freq: 5e3
    low_cutoff_freq: 5e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1'
    low_cutoff_freq: '0'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/miman/Desktop/CUAVA-2/yss.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/miman/Desktop/CUAVA-2/nss.bin
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/miman/Desktop/CUAVA-2/file-sink-wf_new.raw
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: /home/miman/Desktop/CUAVA-2/ysspdu.bin
    type: byte
  states: {}
- name: blocks_file_sink_1_0_0
  id: blocks_file_sink
  parameters:
    file: /home/miman/Desktop/CUAVA-2/file-sink-final_band.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_0_1
  id: blocks_file_sink
  parameters:
    file: /home/miman/Desktop/CUAVA-2/nsspdu.bin
    type: byte
  states: {}
- name: blocks_file_sink_1_1
  id: blocks_file_sink
  parameters:
    file: /home/miman/Desktop/CUAVA-2/raw.cfile
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/miman/Desktop/CUAVA-2/data/data1101_2330/raw.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: costas_loop
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: digital_descrambler_bb_0_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: symbol_sync_loop
    max_dev: '1.5'
    osps: '1'
    pfb_mf_taps: rrc_filter_taps
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate/baud_rate/8
    ted_gain: Expected_TED_Gain
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate,samp_rate/4,samp_rate/8)
    type: ccc
  states: {state: disabled}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '7356'
    verbose: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 4e3
    decim: '8'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HANN
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0,agc_mode='automatic',fpga=/home/miman/Desktop/CUAVA-2/hostedx40-latest.rbf,fpga-reload=1
    bb_gain0: usrp_gain
    freq0: freq
    gain0: usrp_gain
    gain_mode0: 'False'
    if_gain0: usrp_gain
    sample_rate: 2.4e6
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After SS"'
    size: '1024'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"No SS"'
    size: '1024'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"After LPF"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Raw"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"After CL"'
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    color1: red
    size: int(samp_rate/100)
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*10
    fc: '0'
    fftsize: '1024'
    name: '"After LPF"'
    type: complex
    wintype: window.WIN_HANN
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*10
    fc: '0'
    fftsize: '1024'
    name: '"Raw"'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*10
    fc: '0'
    fftsize: '1024'
    name: '"After CL"'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: satellites_aalto1_deframer_0
  id: satellites_aalto1_deframer
  parameters:
    threshold: '0'
  states: {state: disabled}
- name: satellites_check_address_0
  id: satellites_check_address
  parameters:
    address: VK2USY
    direction: '"from"'
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_hdlc_deframer_0_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'False'
    max_length: '10000'
  states: {state: disabled}
- name: satellites_hdlc_deframer_0_1
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_nrzi_decode_0_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_nrzi_decode_0_1
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: 400.65e6
    dev_args: bladerf=0,agc_mode='automatic',fpga=/home/miman/Desktop/CUAVA-2/hostedx40-latest.rbf,fpga-reload=1
    samp_rate: 2.4e6
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: bandwidth
    center_freq0: rx_freq
    dev_addr: ''
    dev_args: '""'
    gain0: usrp_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc_xx_1, '0', digital_constellation_decoder_cb_0_0, '0']
- [analog_agc_xx_1, '0', digital_symbol_sync_xx_1, '0']
- [analog_agc_xx_1, '0', qtgui_const_sink_x_0_0, '0']
- [analog_agc_xx_1, '0', qtgui_time_sink_x_0_2, '0']
- [band_pass_filter_0, '0', digital_costas_loop_cc_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_throttle_0_0, '0', band_pass_filter_0, '0']
- [blocks_throttle_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0_0, '0', low_pass_filter_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', satellites_nrzi_decode_0_0, '0']
- [digital_costas_loop_cc_0, '0', analog_agc_xx_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_0_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [digital_costas_loop_cc_0, '1', qtgui_number_sink_0, '0']
- [digital_descrambler_bb_0, '0', satellites_nrzi_decode_0_1, '0']
- [digital_descrambler_bb_0_0, '0', satellites_hdlc_deframer_0_1, '0']
- [digital_symbol_sync_xx_1, '0', digital_constellation_decoder_cb_0, '0']
- [digital_symbol_sync_xx_1, '0', qtgui_const_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [low_pass_filter_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_1, '0']
- [low_pass_filter_0, '0', digital_costas_loop_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_1_1, '0']
- [osmosdr_source_0, '0', blocks_throttle_0_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_1_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_1_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_file_sink_1_0_1, '0']
- [satellites_check_address_0, ok, blocks_message_debug_0_1, print_pdu]
- [satellites_check_address_0, ok, pdu_pdu_to_tagged_stream_0_1, pdus]
- [satellites_hdlc_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_hdlc_deframer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_hdlc_deframer_0_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_hdlc_deframer_0_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [satellites_hdlc_deframer_0_1, out, satellites_check_address_0, in]
- [satellites_nrzi_decode_0, '0', digital_descrambler_bb_0, '0']
- [satellites_nrzi_decode_0_0, '0', blocks_file_sink_0_0, '0']
- [satellites_nrzi_decode_0_0, '0', digital_descrambler_bb_0_0, '0']
- [satellites_nrzi_decode_0_1, '0', satellites_hdlc_deframer_0, '0']
- [soapy_bladerf_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
